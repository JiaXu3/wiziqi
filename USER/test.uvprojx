# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\WDG;..\HARDWARE\WWDG;..\HARDWARE\TIMER;..\HARDWARE\SENSOR_trailing;..\HARDWARE\PWM;..\HARDWARE\TFTLCD;..\HARDWARE\PID;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\24CXX;..\HARDWARE\HC_SR04;..\HARDWARE\L298N;..\HARDWARE\W25QXX;..\HARDWARE\W25QXX;..\TEXT;..\MALLOC;..\FATFS\exfuns;..\FATFS\src\option;..\HARDWARE\SDIO;..\HARDWARE\TPAD;..\FATFS\src;..\HARDWARE\TOUCH;..\USMART;..\APP;..\HARDWARE\RNG;..\HARDWARE\EXIT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TFTLCD/: tftlcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/W25QXX/: spi.c w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/EXIT/: exit.c
    ../HARDWARE/BEEP/: beep.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group APP
    ../APP/: game.c
